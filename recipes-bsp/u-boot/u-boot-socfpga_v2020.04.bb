require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2020.04"

SRCREV = "cfa15875c66c8e91a0b440332b034e522daa6c45"
