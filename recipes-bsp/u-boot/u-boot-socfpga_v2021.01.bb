require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2021.01"

SRCREV = "e59d8e9eaa14d2164fe4dac4ab0fa7f5dca3a0fe"
