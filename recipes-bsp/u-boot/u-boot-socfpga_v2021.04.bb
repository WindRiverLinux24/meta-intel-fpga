require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2021.04_RC"

SRCREV = "969f82ff5c24317298ea3e77f68746ddb8906bf4"
