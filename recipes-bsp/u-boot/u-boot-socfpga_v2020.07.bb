require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2020.07"

SRCREV = "ba1c57e617cec2a8179d42d4c5b347f2cc3da634"
