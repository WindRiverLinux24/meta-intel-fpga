require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2021.07_RC"

SRCREV = "cf044ae836127edb59c06ca93c8de3ab887b61b4"
