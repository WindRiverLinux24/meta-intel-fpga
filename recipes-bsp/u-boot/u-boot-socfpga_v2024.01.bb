require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2024.01"

SRCREV = "1bf16610b2d49dc2327f68aa5fa215ed291fb899"
