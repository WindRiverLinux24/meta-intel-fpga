require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.10"

SRCREV = "c99037e48bea18b0c23ae6b69669d5edc22fb9ce"
