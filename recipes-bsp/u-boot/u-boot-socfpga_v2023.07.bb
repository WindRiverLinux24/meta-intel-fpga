require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2023.07"

SRCREV = "d84e0d72bfa2cb63bf4fb61cb75f4792aa769c5c"
