require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "v2020.10"

SRCREV = "ced41867be2d09f4a8af2cc33f45c8ee7a67c6fe"
