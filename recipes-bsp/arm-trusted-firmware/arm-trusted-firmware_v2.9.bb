require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.9.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "c3aa093d7656be0abcada8b72a0308264bef066f"
