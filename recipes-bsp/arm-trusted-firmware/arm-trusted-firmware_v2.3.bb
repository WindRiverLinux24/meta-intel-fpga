require arm-trusted-firmware.inc

ATF_BRANCH = "socfpga_v2.3"

SRCREV = "b883cb8f21862cf7a1b2097e749533b3335944e0"
