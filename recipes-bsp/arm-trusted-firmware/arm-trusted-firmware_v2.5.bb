require arm-trusted-firmware.inc

ATF_VERSION = "v2.5.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "929ea02200efb3a95eb9425c467112064dab888e"
