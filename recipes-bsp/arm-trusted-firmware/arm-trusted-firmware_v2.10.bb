require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.10.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "47d7a282f537de0d5a01546c1f7cf446dd3c9be1"