require arm-trusted-firmware.inc

ATF_VERSION = "v2.4.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "a85a93ebdc0bb80a06343bc436e9f2a81aff2b09"
