LINUX_VERSION = "6.6.22"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "f939c80e4195178b511c7577e0dc2a570ca0a426"

include linux-socfpga.inc
