LINUX_VERSION = "6.1.68"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "56be5baba0b5ad557fe81a72ceb9ba2adba0e57d"

include linux-socfpga.inc
